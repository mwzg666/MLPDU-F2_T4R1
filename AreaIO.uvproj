# Keil uVision project AreaIO.uvproj, settings and files
target AreaIO (MCS-251)
  device: STC32G12K128 Series STC
  cpu: IRAM(0-0xFFF) XRAM(0x10000-0x11FFF) IROM(0xFE0000-0xFFFFFF) CLOCK(35000000)
  output: PileCore +hex
  link misc: REMOVEUNUSED
  group USER
    ./USER/: main.c
  group Hardware
    ./Hardware/Usart/: uart.c
    ./Hardware/TIM/: time.c
    ./Hardware/I2C/: i2c.c
    ./Hardware/mcp4725/: mcp4725.c
    ./Ads1110/: ads1110.c
    ./MwPro/: cmd.c MwPro.c
